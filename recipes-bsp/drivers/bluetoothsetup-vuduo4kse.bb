require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuduo4kse)$"

SRCDATE = "20200909"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "29f025fa91f4759bc9be29148339e2de"
SRC_URI[sha256sum] = "23146d570ba16b422b3ae199289084e55cc5e00d1e812a741837132133453402"

require vuplus-dvb-modules.inc

KV = "3.13.5"

DOWNLOADMACHINE = "${MACHINE}"

SRCDATE = "20141231"
SRC_URI[md5sum] = "74cb258ef7aeb49d55c0383c49de7b5e"
SRC_URI[sha256sum] = "bce7e1a2432af66a0b158b64b471efc0722e1f0c0f052cae1cf6f1f9732cc169"

require vuplus-platform-util.inc

PV="15.2"
SRCDATE = "20161115"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "a955d86ed162df240f32d5c876079e93"
SRC_URI[sha256sum] = "ed503e8533d021e04bab40efe727749f405438c42a4ff425d7932f2f35165c42"

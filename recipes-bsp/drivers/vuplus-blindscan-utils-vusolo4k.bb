require vuplus-blindscan-utils-arm.inc

FILES_vuplus-blindscan-dvbc-utils-${MACHINE} = "\
	${bindir}/ssh108 \
	${bindir}/tt3l10 \
	${bindir}/tt2l08 \
"

FILES_vuplus-blindscan-dvbt-utils-${MACHINE} = "\
	${bindir}/ssh108_t2_scan \
	${bindir}/tt3l10_t2_scan \
	${bindir}/tt2l08_t2_scan \
"


FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append_vusolose = " file://enigma2_rc_vusolose.patch"


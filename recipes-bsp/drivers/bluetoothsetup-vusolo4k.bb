require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vusolo4k)$"

SRCDATE = "20200812"
SRCDATE_PR = "r1"

SRC_URI[sha256sum] = "0e2c84221677c9250c26644df932323c8ca75f5ba4aaeeb507d15f94894be168"

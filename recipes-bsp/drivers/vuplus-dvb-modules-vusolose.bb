require vuplus-dvb-modules.inc

KV = "3.13.5"

DOWNLOADMACHINE = "${MACHINE}"

SRCDATE = "20150511"
SRC_URI[md5sum] = "9f1e71a4530952604a07ef431738cddf"
SRC_URI[sha256sum] = "5558f262a204c952e3d2c5b89acf2d28fe8c9e0cfb8ad75d892344d1bddb40c9"

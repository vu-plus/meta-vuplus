require vuplus-blindscan-utils-arm.inc
COMPATIBLE_MACHINE = "^(vuduo4k)$"

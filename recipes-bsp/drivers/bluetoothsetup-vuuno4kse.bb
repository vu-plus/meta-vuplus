require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuuno4kse)$"

SRCDATE = "20200812"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "024ddd739bfc42124bb820bb9bbb6120"
SRC_URI[sha256sum] = "4a121859f5fa8a660b87020654748c10d648668e2b3cd86afea0203cf57295b5"

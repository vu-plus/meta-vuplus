require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuultimo4k)$"

SRCDATE = "20200812"
SRCDATE_PR = "r5"

SRC_URI[md5sum] = "c2b450e62f96641f7fda693101beb2f3"
SRC_URI[sha256sum] = "8c7e1f9e09a2a8a7d4809d2e94c99d49a893028f5fbc7679c4bfdf02942b3b27"


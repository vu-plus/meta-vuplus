require vuplus-blindscan-utils-mipsel.inc

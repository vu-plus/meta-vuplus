require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuzero4k)$"

SRCDATE = "20200812"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "811b9ddfd2b00d5a71ffdfae207baed1"
SRC_URI[sha256sum] = "e73a3c3865a8405bb5c3e56e07909b1cf7d8ba2a08690ff20770445c46676a9c"

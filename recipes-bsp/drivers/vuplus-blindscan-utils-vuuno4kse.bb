require vuplus-blindscan-utils-arm.inc
COMPATIBLE_MACHINE = "^(vuuno4kse)$"

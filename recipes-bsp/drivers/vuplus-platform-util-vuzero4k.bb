require vuplus-platform-util.inc

PV="17.1"
SRCDATE = "20180208"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "5258517d9f2f855a8984e7daa5f4c5d4"
SRC_URI[sha256sum] = "43282c9a6237bd44e3abfce97d3926cc58fe24f03af229d9aff22eef36c94666"

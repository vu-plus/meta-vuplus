require libgles.inc

SRCDATE = "20181120"
SRCDATE_PR = "r0"
PV="18.1"


SRC_URI[md5sum] = "54a1d6237d7c49e31535a26f06612342"
SRC_URI[sha256sum] = "c0ddf9d5e81508c3eb9b12c0b89786f0028b8ea1cb1c48b5e5a022e052a33f03"

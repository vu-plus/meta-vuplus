require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuduo4k)$"

SRCDATE = "20221118"
SRCDATE_PR = "r1"

SRC_URI[md5sum] = "f621e95b938fd33402a94707ae4fe1c3"
SRC_URI[sha256sum] = "74e72062e4ce4c141c465d1c895ec926a7342e84ac8480cb41cf80cebf3cbee6"

require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "${MACHINE}"

SRCDATE = "20140808"
SRC_URI[md5sum] = "1b9698f4ce75d1a4878f978692bcbeed"
SRC_URI[sha256sum] = "6094109be167b0335c2fb3a069f01365de03c814a56737a662d9fc70e892642f"

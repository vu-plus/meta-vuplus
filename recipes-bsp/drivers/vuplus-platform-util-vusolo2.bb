require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vusolo2)$"

SRCDATE = "20171121"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "ccd90d6d1556aa35eaa44b686421131f"
SRC_URI[sha256sum] = "15bbf8f77c4321d3c7e0ba5c2c0a31ad1172628db57f93dd6db624e5ec13bb08"

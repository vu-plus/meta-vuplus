require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vuduo2)$"

SRCDATE = "20171204"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "127d4d53789bcaf776149071239415e4"
SRC_URI[sha256sum] = "7e1d4de00bb5c2736595d57545b01b0542589d6257b2dff49d9cd995a6e0cd6c"

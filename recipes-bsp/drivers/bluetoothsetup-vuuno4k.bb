require bluetoothsetup.inc

COMPATIBLE_MACHINE = "^(vuuno4k)$"

SRCDATE = "20200812"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "69ca604d5dad9a3d7e88dbf08e03db54"
SRC_URI[sha256sum] = "38ef0f7b3723c9b8ee7a922bb9150c35b3c488e7fb54a240a405e42c2b8152b6"

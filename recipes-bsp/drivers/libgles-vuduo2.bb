require libgles.inc

COMPATIBLE_MACHINE = "^(vuduo2)$"

SRCDATE = "20171127"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "8bf248630ab755ae3a49a5f48bdcc4c9"
SRC_URI[sha256sum] = "4acd92280a4d4bcc140c75b21a65f5625a4d913e67aab653cddfaa90a00ecb1a"

require vuplus-platform-util.inc

PV="16.1"
SRCDATE = "20180208"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "67c5953e1a0682ce19f0c1cca6cc811e"
SRC_URI[sha256sum] = "9500d37b2bcbab346fd7978180ad7ccac22675dd536e89e0fdc53e634f757003"

require vuplus-blindscan-utils.inc

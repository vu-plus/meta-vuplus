require vuplus-blindscan-utils-mipsel.inc
COMPATIBLE_MACHINE = "^(vusolo2)$"

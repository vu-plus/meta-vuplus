require vuplus-dvb-modules.inc

KV = "3.13.5"

DOWNLOADMACHINE = "${MACHINE}"

SRCDATE = "20141229"
SRC_URI[md5sum] = "60b4825a1285addd3102a5f9ac7ed545"
SRC_URI[sha256sum] = "19be925a75e5b6f0873e58a3a54e3b0942b56568afc6341d4d5f9bafa8b566cb"

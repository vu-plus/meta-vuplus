require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "${MACHINE}"

SRCDATE = "20150511"
SRC_URI[md5sum] = "254becccff3917a1c14498bc6ff67161"
SRC_URI[sha256sum] = "39ce71bafdc13e89deec4896f34ea2cc476438284c83663a5a5dc55d4639dcb0"

require vuplus-platform-util.inc

COMPATIBLE_MACHINE = "^(vusolose)$"

SRCDATE = "20170822"
SRCDATE_PR = "r0"

SRC_URI[md5sum] = "f3dfb440411b383d93d751e6f827acbb"
SRC_URI[sha256sum] = "1e63df4b4ff14d6f7a6da9af204133cce9581e74310ad26d79d5b4dd54954534"

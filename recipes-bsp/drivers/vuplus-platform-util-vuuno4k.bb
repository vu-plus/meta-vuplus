require vuplus-platform-util.inc

PV="16.1"
SRCDATE = "20180209"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "812239ae7841594188d1fb7e6b2b3693"
SRC_URI[sha256sum] = "31bff8570050af181fb8b413fc293c8446450eab7997b3b0fcf9e94d81b2f3a1"

require vuplus-dvb-modules.inc

DOWNLOADMACHINE = "${MACHINE}"

SRCDATE = "20150109"
SRC_URI[md5sum] = "bf461f578fd460da34145e3ea196646d"
SRC_URI[sha256sum] = "303d248ee5cdebd62d153de21b67db965d7e05c654268f5e1fe17bdc8b85bcd0"

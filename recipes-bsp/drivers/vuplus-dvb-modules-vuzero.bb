require vuplus-dvb-modules.inc

KV = "3.13.5"

DOWNLOADMACHINE = "${MACHINE}"

SRCDATE = "20150511"
SRC_URI[md5sum] = "f6454ce56a92bf496f10972192da3653"
SRC_URI[sha256sum] = "315e9daa75806f97c42d9fc429932d1ebf58cac4659623e08d225eaa446cc080"

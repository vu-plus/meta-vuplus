require vuplus-platform-util.inc

PV="16.1"
SRCDATE = "20180209"
SRCDATE_PR = "r0"


SRC_URI[md5sum] = "dfb94c20c3f7de372dd10eab7415136a"
SRC_URI[sha256sum] = "b5ae1923b11169377c1e6ec36263fb46869e2cca69c83bbeaadd8b8ee0843d33"

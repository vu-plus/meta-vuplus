require vuplus-blindscan-utils-arm.inc
COMPATIBLE_MACHINE = "^(vuultimo4k)$"

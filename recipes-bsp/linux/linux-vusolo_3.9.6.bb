require linux-vuplus-3.9.6.inc

MACHINE_KERNEL_PR_append = "${PR_INC}.3"

COMPATIBLE_MACHINE = "vusolo"

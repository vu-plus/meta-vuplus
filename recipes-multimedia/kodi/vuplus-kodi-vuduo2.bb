require vuplus-kodi.inc

COMPATIBLE_MACHINE = "^(vuduo2)$"

PV = "1.0"

GLPR = "20160331_r0"

SRC_URI[md5sum] = "f3db678550f3654fcc8dfbb875678943"
SRC_URI[sha256sum] = "758e75966c1ca513bbeb7eaef0d0359207232ba0e7f4f5e2574c146f5e09cab3"
